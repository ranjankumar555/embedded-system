# Keil uVision project can1rx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: can1rx +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s
    ../Node B (RX)/: can1_rx_inte.c delay.c hcsr04.c nodeB_driver.c nodeB_main.c uart0_driver.c header.h
    ../can2_tx/: p1.ini
