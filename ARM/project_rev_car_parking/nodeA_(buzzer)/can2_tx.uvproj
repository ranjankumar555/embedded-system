# Keil uVision project can2_tx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: nodeA_buzzer +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s p1.ini
    ../Node A (TX)/: uart0_driver.c can_rx_inte.c delay.c eint0.c nodeA_driver.c nodeA_main.c headerb.h
    ../../LCD4bit_interfacing/: lcd4bitDriver.c
